SRC_URI = "git://github.com/armbian/rkbin.git;branch=master;protocol=https"
